Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: HLUM 60_75_100_120W-360.IFC
Time: 2023-10-23T06:48:53
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: HLUM 60_75_100_120W-360
In: Default Storey
SolidWorks Custom Properties - Description: PWR(60,75,100,120W);LUM.FLUX(8740-16000lm)
PSet_Mass_Property - Mass Measure: 7.52826; Area Measure: 0.383654 m2; Volume Measure: 0.00752826 m3
