Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: HLUM 130_150_180_220W-590.IFC
Time: 2023-10-23T06:48:15
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: HLUM 130_150_180_220W-590
In: Default Storey
SolidWorks Custom Properties - Description: PWR(130,150,180,220W);LUM.FLUX(19300-31400lm)
PSet_Mass_Property - Mass Measure: 12.4997; Area Measure: 0.595593 m2; Volume Measure: 0.0124997 m3
