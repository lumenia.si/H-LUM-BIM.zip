Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: HLUM 170_220_260W-800.IFC
Time: 2023-10-23T06:48:35
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: HLUM 170_220_260W-800
In: Default Storey
SolidWorks Custom Properties - Description: PWR(170,220,260W);LUM.FLUX(25100-42100lm)
PSet_Mass_Property - Mass Measure: 17.0431; Area Measure: 0.788687 m2; Volume Measure: 0.0170431 m3
