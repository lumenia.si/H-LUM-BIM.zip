Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: HLUM 95_110_135_150W-460.IFC
Time: 2023-10-23T06:49:11
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: HLUM 95_110_135_150W-460
In: Default Storey
SolidWorks Custom Properties - Description: PWR(95,110,135,150W);LUM.FLUX(13800-21400lm)
PSet_Mass_Property - Mass Measure: 9.68878; Area Measure: 0.476053 m2; Volume Measure: 0.00968878 m3
